# Keil uVision project digitalalarm.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: enviroclk +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s adc.c adc.h delay.c delay.h pin_block.h pin_block_defines.h pin_connect_block.c lcd.c lcd.h lcd_defines.h types.h rtc_defines.h rtc.h rtc.c clockmain.c adc_defines.h kpm_defines.h kpm.h kpm.c defines_reg.h
